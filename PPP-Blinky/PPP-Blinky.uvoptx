<?xml version="1.0" encoding="utf-8"?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">
	<SchemaVersion>1.0</SchemaVersion>
	<Target>
		<TargetName>PPP-Blinky</TargetName>
		<ToolsetNumber>0x4</ToolsetNumber>
		<ToolsetName>ARM-ADS</ToolsetName>
		<TargetOption>
			<DebugOpt>
				<uSim>0</uSim>
				<uTrg>1</uTrg>
				<nTsel>11</nTsel>
				<pMon>BIN\CMSIS_AGDI.dll</pMon>
			</DebugOpt>
			<TargetDriverDllRegistry>
				<SetRegEntry>
					<Number>0</Number>
					<Key>CMSIS_AGDI</Key>
					<Name>UL2CM3(-S0 -C0 -P0 -FD20000000 -FC1000 -FN1 -FF0mkwxxz_p512_2kb_sec -FS000000000 -FL000080000 -FP0($$Device:MKW41Z512xxx4$Flash/MKWxxZ_P512_2KB_SEC.FLM))</Name>
				</SetRegEntry>
			</TargetDriverDllRegistry>
		</TargetOption>
	</Target>
</ProjectOpt>